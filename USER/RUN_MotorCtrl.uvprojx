# Keil uVision project RUN_MotorCtrl.uvprojx, settings and files
target RUNIII_Motor_Ctrl (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SensorBoard_v1.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER, UART1_PRINTF
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\CAN;..\HARDWARE\DS18B20;..\HARDWARE\IIC;..\SYSTEM;..\USER;..\FreeRTOS\SystemView\Src\Config;..\FreeRTOS\SystemView\Src\FreeRTOSV9;..\FreeRTOS\SystemView\Src\SEGGER;..\HARDWARE\MotorControl
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/CAN/: can.c canard.c
    ../HARDWARE/MotorControl/: exDCMotor.c
    ../HARDWARE/DS18B20/: DS18.c
    ../HARDWARE/ADC/: OCPSampling.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c timerapp.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_exti.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group SystemView
    ../FreeRTOS/SystemView/Src/FreeRTOSV9/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../FreeRTOS/SystemView/Src/FreeRTOSV9/: SEGGER_SYSVIEW_FreeRTOS.c
    ../FreeRTOS/SystemView/Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
